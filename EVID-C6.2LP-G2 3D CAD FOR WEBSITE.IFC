Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: STD-C6.2LP 3D CAD FOR WEBSITE.IFC
Time: 2024-11-08T02:24:03
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4扁平吊环2^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RLP^STD-C6.2LP 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C6.2LP 后桶圆顶端子盖^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C6.2LP 后桶新设计^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C8.1S 铁网^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron14寸2_預設^STD-C6.2LP 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 挂钩新设计2_預設^STD-C6.2LP 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel
