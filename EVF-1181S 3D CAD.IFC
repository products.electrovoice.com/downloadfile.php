Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVF-1181S 3D CAD.IFC
Time: 2023-02-01T06:32:24
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVF-1181S EV Logo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVF-1181S Grille
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVF-1181S Rear Panel
In: Default Storey
Material: ABS
