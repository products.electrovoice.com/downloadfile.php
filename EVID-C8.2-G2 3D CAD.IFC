Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: STD-C8.2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-08T04:12:27
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-R2^STD-C8.2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 8寸后桶 加圆顶^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 8寸后桶端子盖 加圆顶^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron12_預設^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环12^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 挂钩新设计_預設^STD-C8.2 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网212^STD-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
