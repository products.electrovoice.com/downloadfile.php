Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EVOLVE 30M 3D CAD.IFC
Time: 2022-07-25T16:18:13
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Evolve 30M Amp Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Bottom Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Column Handle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M EV Logo
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Long Pole
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Long Pole Cover A
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Long Pole Cover B
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Rear Enclosure
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Rubber Foot (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Short Pole
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Short Pole Cover A
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Short Pole Cover B
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Sub Handle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Sub Handle Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Sub Top Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Subwoofer Cabinet
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Subwoofer Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Evolve 30M Top Cover
In: Default Storey
PredefinedType: ELEMENT; Material: 0
