Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ZLX200-8P 3D CAD.IFC
Time: 2023-04-03T02:10:57
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ZLX200-8P Display
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: ZLX200-8P EV Logo
In: Default Storey
Material: Zinc AC41A Alloy, As Cast

# IfcBuildingElementProxy: ZLX200-8P Grille
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: ZLX200-8P Handle_insert
In: Default Storey
Material: PP Copolymer
