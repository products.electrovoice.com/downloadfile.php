Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: C4.2-G2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-11T05:28:53
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准3寸铁网4^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准sheet iron4_預設^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准吊环4^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准后桶 圆顶 端子盖^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RLP^C4.2-G2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^C4.2-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 挂钩新设计2_預設^C4.2-G2 3D CAD FOR WEBSITE (3)
In: Default Storey
Material: Steel
