Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVA-2151D Middle Element with Extended Grid 3D CAD.IFC
Time: 2023-03-13T03:50:20
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVA-2151D Cover Plate (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2151D EV Logo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2151D EVA Tie Plate (2)
In: Default Storey
Material: 6061 Alloy

# IfcBuildingElementProxy: EVA-2151D Grille
In: Default Storey
Material: Galvanized Steel

# IfcBuildingElementProxy: EVA-2151D Rear Panel
In: Default Storey
Material: ABS
