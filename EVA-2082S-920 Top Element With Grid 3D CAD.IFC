Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVA-2082S-920 Top Element With Grid 3D CAD.IFC
Time: 2023-03-13T07:52:09
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVA-2082S-920 Cover Plate (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 EV Logo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 EVA Grid Left Side
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 EVA Grid Right Side
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 Extended Grid (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 Grille
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-920 Rear Panel
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: EVA-2082S-920 Spreader Bar
In: Default Storey
Material: Steel
