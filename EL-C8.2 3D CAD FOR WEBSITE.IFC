Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EL-C8.2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-07T05:56:08
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1Prop Stand21E_預設^EL-C8.2 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-R2EL^EL-C8.2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 8寸后桶 加圆顶EL^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 8寸后桶端子盖 加圆顶EL^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron12EL_預設^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环12EL^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网212EL^EL-C8.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
