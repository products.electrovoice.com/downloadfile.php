Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: STD-C8.1S 3D CAD FOR WEBSITE.IFC
Time: 2024-11-08T03:10:07
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-R2^STD-C8.1S 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C8.1 端子盖 圆顶^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C8.1S 后桶新设计^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: guajian12^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: guajian22^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron2_預設^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环2^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 挂钩新设计2_預設^STD-C8.1S 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网凸起5^STD-C8.1S 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
