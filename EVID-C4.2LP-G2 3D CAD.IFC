Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: STD-C4.2LP-G2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-11T06:15:22
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4寸后桶 更新加圆顶 端子盖^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4寸后桶 更新加圆顶^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RLP^STD-C4.2LP-G2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron14寸LP_預設^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环14寸LP^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 挂钩新设计_預設^STD-C4.2LP-G2 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网214寸LP^STD-C4.2LP-G2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
