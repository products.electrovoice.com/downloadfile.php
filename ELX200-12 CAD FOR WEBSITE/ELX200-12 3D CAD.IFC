Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ELX200-12 3D CAD.IFC
Time: 2022-04-15T01:48:43
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ELX200-12 3D CAD
In: Default Storey
Material: Steel
