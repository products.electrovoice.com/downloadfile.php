Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: ELX200-10 3D CAD.IFC
Time: 2022-01-05T17:26:34
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ELX200-10 3D CAD
In: Default Storey
PredefinedType: ELEMENT; Material: Material <not specified>
