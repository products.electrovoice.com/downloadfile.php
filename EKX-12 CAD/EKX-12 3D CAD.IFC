Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EKX-12 3D CAD.IFC
Time: 2022-10-07T14:39:57
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EKX-12 Amplifier Cord Receptacle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier Display Glass
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier Knob 1 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier Knob 2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier Power Switch
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier RCA Jack
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier XLR Female
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Amplifier XLR Male (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 EV Logo
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Foot (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Handle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Monitor Foot (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EKX-12 Pole Mount
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: NONE (8)
In: Default Storey
PredefinedType: ELEMENT
