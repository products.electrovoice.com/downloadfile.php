Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVA-EG2.IFC
Time: 2021-05-13T06:14:13
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: F01U195762
In: Default Storey
Material: Steel

# IfcBeam: PAR000915
In: Default Storey
Material: 6061 Alloy

# IfcBuildingElementProxy: F01U195762
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: F01U200010
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: FST000109_92610A346 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: PAR000915
In: Default Storey
Material: 6061 Alloy
