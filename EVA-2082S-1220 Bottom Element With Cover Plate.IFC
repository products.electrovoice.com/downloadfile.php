Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVA-2082S-1220 Bottom Element With Cover Plate.IFC
Time: 2023-03-14T06:31:39
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVA-2082S-1220 Cover Plate (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-1220 EV Logo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-1220 Grille
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-2082S-1220 Rear Panel
In: Default Storey
Material: ABS
