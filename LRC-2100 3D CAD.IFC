Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: LRC-2100 3D CAD FOR WEBSITE.IFC
Time: 2024-08-30T01:36:24
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 8X13X2.5 WATER- AND STEAM-RESISTANT HIGH-TEMPERATURE EPDM O-RING_1289N349
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 90221A607_PUSH-IN RIVETS WITH RIBBED SHANK_90221A607 (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: F01U424801_SIMPLIFIED
In: Default Storey
Material: ABS PC

# IfcBuildingElementProxy: F01U427515_90269A256 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: LRC-2100 BRACKET BASE PLATE
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-2100 BRACKET HINGE PIN
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: LRC-2100 ENCLOSURE
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-2100 EV LOGO
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: LRC-2100 GRILLE SIMPLIFIED
In: Default Storey
Material: 1060 Alloy

# IfcBuildingElementProxy: LRC-2100 PAN BRACKET
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-2100 TILT BRACKET
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-2100 WIDE NARROW SWITCH
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: M10X18 18-8 Stainless Steel Flanged Button Head Screw_97654A670 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M6X16_BUTTON HEAD 5MM HEX DRIVE SCREW_92095A238 (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M8 18-8 Stainless Steel Cap Nylon Lock Nut_94000A039
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M8X25_CORROSION-RESISTANT FULLY THREADED ROD END BOLT_2434K883
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: M8X95 18-8 Stainless Steel Socket Head Screw_91292A523
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: PUSH-IN RIVETS WITH RIBBED SHANK FOR 8MM HOLE SIZE_90221A607 (2)
In: Default Storey
Material: Steel
