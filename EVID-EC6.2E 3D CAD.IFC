Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EL-C6.2E 3D CAD FOR WEBSITE.IFC
Time: 2025-04-23T05:13:50
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1Prop Stand21E_預設^EL-C6.2E 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 1sheet iron1E_預設^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 1吊环1E^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 25-020-01AN-R_預設^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RE^EL-C6.2E 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EL 62后桶圆顶^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STDC62后桶圆顶端子盖^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网214寸E^EL-C6.2E 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
