Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EL-C3.1 3D CAD FOR WEBSITE.IFC
Time: 2024-11-07T03:08:25
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 3寸桶1
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 3寸端子盖圆顶
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 3寸铁网1
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RLPEL (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Prop Stand21_預設 (3)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron1_預設
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环1
In: Default Storey
Material: Steel
