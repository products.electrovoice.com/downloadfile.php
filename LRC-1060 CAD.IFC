Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: LRC-1060 CAD FOR WEBSITE.IFC
Time: 2024-08-22T03:59:14
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 90221A607_PUSH-IN RIVETS WITH RIBBED SHANK_SIMPLIFIED_90221A607 (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: F01U422225_CAD FOR WEB
In: Default Storey
Material: ABS PC

# IfcBuildingElementProxy: F01U424711
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: LRC-1060 BRACKET BASE PLATE
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-1060 ENCLOSURE
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: LRC-1060 EV LOGO
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: LRC-1060 GRILLE
In: Default Storey
Material: 1060-H18

# IfcBuildingElementProxy: LRC-1060 PAN BRACKET
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-1060 TILT BRACKET
In: Default Storey
Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: LRC-1060 WIDE NARROW SWITCH
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: M6X16_BUTTON HEAD 5MM HEX DRIVE SCREW_92095A238 (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M6X65 18-8 Stainless Steel 5mm Hex Head Screw_93856A223
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M8X16 18-8 Stainless Steel Flanged Button Head Nylon Lock Screw_97654A383 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: M8X25_CORROSION-RESISTANT FULLY THREADED ROD END BOLT CAD FOR WEB_2434K883
In: Default Storey
Material: AISI 304
