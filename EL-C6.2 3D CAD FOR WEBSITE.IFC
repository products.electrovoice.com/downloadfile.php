Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EL-C6.2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-07T03:32:20
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1Prop Stand21_預設^EL-C6.2 3D CAD FOR WEBSITE (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 1sheet iron1_預設^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 1吊环1^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 25-020-01AN-R_預設^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-R^EL-C6.2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EL 62后桶圆顶0.8mm^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EL-C6.2新塑料筐修改^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STDC62后桶圆顶端子盖^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 铁网214寸^EL-C6.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
