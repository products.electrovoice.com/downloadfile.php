Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVF-1122 3D CAD.IFC
Time: 2021-07-23T20:43:17
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EVF-1122 Grille
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVF-1122 EV Logo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVF-1122 Gland Nut Panel
In: Default Storey
Material: Steel
