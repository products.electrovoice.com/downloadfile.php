Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: MTS-6154-64 3D CAD.IFC
Time: 2021-07-14T01:58:20
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
