Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EL-C4.2 3D CAD FOR WEBSITE.IFC
Time: 2024-11-06T06:46:59
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1Prop Stand21E_預設^EL-C4.2 3D CAD FOR WEBSITE (3)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 25-020-01AN-R_預設^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准3寸桶4EL^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准3寸铁网4EL^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准sheet iron4EL_預設^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准吊环4EL^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 4标准后桶 圆顶 端子盖EL^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN-RLPEL^EL-C4.2 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02CN-R^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: SE-038-02DN-R^EL-C4.2 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
