Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ZLX-12 3D CAD.IFC
Time: 2022-04-24T03:11:08
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ZLX-12 3D CAD
In: Default Storey
Material: Steel
