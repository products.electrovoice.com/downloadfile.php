Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: EVA-GXB 3D CAD.IFC
Time: 2023-04-20T05:42:15
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVA-GXB Rigging Pad UMHW (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-GXB Rigging Screw_92610A346 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-GXB Rigging Spreader Bar
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EVA-GXB Rigging Washer (2)
In: Default Storey
Material: Steel
