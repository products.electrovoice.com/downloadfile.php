Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EVF-2151D 3D CAD.IFC
Time: 2023-01-23T16:04:57
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EVF-2151D EV Logo
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EVF-2151D Enclosure Back Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Enclosure Side Panel (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Enclosure Top and Bottom Panel (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Gland Nut 1 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Gland Nut 2 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Gland Nut 3 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EVF-2151D Gland Nut Panel
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EVF-2151D Grille
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EVF-2151D Input Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0
