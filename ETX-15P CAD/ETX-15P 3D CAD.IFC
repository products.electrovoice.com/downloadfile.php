Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: ETX-15P 3D CAD.IFC
Time: 2022-09-26T21:12:47
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ETX-15P Amplifier Cord Receptacle
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier Cup
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier Display Glass
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: ETX-15P Amplifier Knob 1 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier Knob 2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier Panel
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier Power Switch
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier XLR Female
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Amplifier XLR Male (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P EV Logo
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Foot (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Grille
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Handle (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Handle Cover (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Monitor Foot (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ETX-15P Pole Mount
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: NONE (8)
In: Default Storey
PredefinedType: ELEMENT
