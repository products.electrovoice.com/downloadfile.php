Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: STD-C8.2HC 3D CAD FOR WEBSITE.IFC
Time: 2024-11-11T03:52:53
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 25-020-01AN-R_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 64-425-02AN_預設^STD-C8.2HC 3D CAD FOR WEBSITE (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: BOSCH_STD-C8.2HC_90W Grill^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C8.2HC 端子盖 圆顶_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: STD-C8.2HC_Backcan _預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: guajian12_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: guajian22_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: sheet iron2_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 吊环2_預設^STD-C8.2HC 3D CAD FOR WEBSITE
In: Default Storey
Material: Steel
